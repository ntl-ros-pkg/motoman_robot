Commit message: [modify] toolの位置を変更
t軸から0.040[mm]の位置に変更

File: robots/sia5/sia5.urdf (robot description, URDF)
Before this commit: robot sia5, 10 links, 9 joints
Joints:
- joint joint_tool0: origin xyz=0.0115 0 0 rpy=0 0 0 -> xyz=0.0115 0 -0.040 rpy=0 0 0
